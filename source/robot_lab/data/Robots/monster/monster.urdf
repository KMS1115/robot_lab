Commit message: 04/07 Feat: add monster train pipeline

File: source/robot_lab/data/Robots/monster/monster.urdf (robot description, URDF)
Before this commit: robot monster, 19 links, 18 joints
Links:
- removed link king
Joints:
- removed joint king
